# Keil uVision project Logger.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ADuCM360 Analog Devices
  pack: AnalogDevices.ADuCM36x_DFP.1.0.4
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Logger +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;.\Src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c
    ./Src/: BoardInit.c Pins.c crc8.c
    ./Inc/: Pins.h crc8.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
